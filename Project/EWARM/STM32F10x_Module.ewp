# IAR project STM32F10x_Module.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: ..\; ..\..\Libraries\CMSIS\CM3\CoreSupport; ..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\Project; ..\..\STM32_EVAL\Common; ..\..\STM32_EVAL\STM3210B_EVAL; ..\..\STM32_EVAL\STM3210C_EVAL; ..\..\STM32_EVAL\STM3210E_EVAL; ..\..\STM32_EVAL\STM32100B_EVAL; ..\..\STM32_EVAL\STM32100E_EVAL; ..\..\STM32_EVAL; ..\..\Project; ..\..\Project\APP; ..\..\Project\BSP; ..\..\Libraries\UCOSIII; ..\..\Libraries\UCOSIII\uC-CPU\Cfg; ..\..\Libraries\UCOSIII\uC-CPU\Ports; ..\..\Libraries\UCOSIII\uC-CPU\Source; ..\..\Libraries\UCOSIII\uC-LIB\Cfg; ..\..\Libraries\UCOSIII\uC-LIB\Ports; ..\..\Libraries\UCOSIII\uC-LIB\Source; ..\..\Libraries\UCOSIII\uCOS-III\Cfg; ..\..\Libraries\UCOSIII\uCOS-III\Ports; ..\..\Libraries\UCOSIII\uCOS-III\TLS; ..\..\Libraries\UCOSIII\uCOS-III\Source; ..\..\Project\BSP\LED
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F10x_Module.hex
  ILINK.IlinkOutputFile: STM32F10x_Module.out
  ILINK.IlinkIcfFile: STM32_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  group (top)
    ../: stm32f10x_conf.h
  group APP
    ../APP/: app.c app_cfg.h includes.h os_type.h
  group BSP
    ../BSP/: bsp.c bsp.h bsp_int.c bsp_int.h bsp_vect.c
  group BSP/LED
    ../BSP/LED/: led.c led.h
  group BSP/wireless
    ../BSP/Wireless/: rf_wireless.c rf_wireless.h
  group CMSIS
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Doc
    ./: readme.txt
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group UCOSIII/uC-CPU/Cfg
    ../../Libraries/UCOSIII/uC-CPU/Cfg/: cpu_cfg.h
  group UCOSIII/uC-CPU/Ports
    ../../Libraries/UCOSIII/uC-CPU/Ports/: cpu.h cpu_a.asm cpu_c.c
  group UCOSIII/uC-CPU/Source
    ../../Libraries/UCOSIII/uC-CPU/Source/: cpu_core.c cpu_core.h cpu_def.h
  group UCOSIII/uC-LIB/Cfg
    ../../Libraries/UCOSIII/uC-LIB/Cfg/: lib_cfg.h
  group UCOSIII/uC-LIB/Ports
    ../../Libraries/UCOSIII/uC-LIB/Ports/: lib_mem_a.asm
  group UCOSIII/uC-LIB/Source
    ../../Libraries/UCOSIII/uC-LIB/Source/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group UCOSIII/uCOS-III/Cfg
    ../../Libraries/UCOSIII/uCOS-III/Cfg/: os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group UCOSIII/uCOS-III/Ports
    ../../Libraries/UCOSIII/uCOS-III/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group UCOSIII/uCOS-III/Source
    ../../Libraries/UCOSIII/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOSIII/uCOS-III/TLS
    ../../Libraries/UCOSIII/uCOS-III/TLS/: os_tls.c
